Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Jun-Coffee Table 110x90 H35 Gres - ver4.ifc
Time: 2024-11-06T15:38:51
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Jun-Coffee Table 110x90 H35 Gres_0 - ObjectType: SketchupGroup
 | Jun-Coffee Table 110x90 H35 Gres_1 - ObjectType: SketchupGroup
 | Jun-Coffee Table 110x90 H35 Gres_2 - ObjectType: SketchupGroup
 | Jun-Coffee Table 110x90 H35 Gres_3 - ObjectType: SketchupGroup
 | Jun-Coffee Table 110x90 H35 Gres_4 - ObjectType: SketchupGroup
 | Jun-Coffee Table 110x90 H35 Gres_5 - ObjectType: SketchupGroup
 | Jun-Coffee Table 110x90 H35 Gres_6 - ObjectType: SketchupGroup
 | Jun-Coffee Table 110x90 H35 Gres_7 - ObjectType: SketchupGroup
